# Keil uVision project 2.4G.uvprojx, settings and files
target 2.4G (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 2.4G +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Composite;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/COMPOSITE/Inc;../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/HID_KEYBOARD/Inc;../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Core/Inc;../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/App;../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Target;../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/CDC_ACM/Inc;../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/HID_MOUSE/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c tim.c usb.c stm32f1xx_it.c stm32f1xx_hal_msp.c usbd_agent.c G24.c ledmatrix.c nrf24l01.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/Composite/USB/COMPOSITE/COMPOSITE
    ../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/COMPOSITE/Src/: usbd_composite.c
  group Middlewares/Composite/USB/COMPOSITE/HID_KEYBOARD
    ../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/HID_KEYBOARD/Src/: usbd_hid_keyboard.c
  group Middlewares/Composite/USB/COMPOSITE/Core
    ../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/App/: usb_device.c usbd_desc.c
    ../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Target/: usbd_conf.c
  group Middlewares/Composite/USB/COMPOSITE/CDC_ACM
    ../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/CDC_ACM/Src/: usbd_cdc_acm.c
    ../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/App/: usbd_cdc_acm_if.c
  group Middlewares/Composite/USB/COMPOSITE/HID_MOUSE
    ../Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/HID_MOUSE/Src/: usbd_hid_mouse.c
software components: CMSIS:CORE 4.3.0
